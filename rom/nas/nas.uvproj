# Keil uVision project nas.uvproj, settings and files
target nas (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: nas +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./: clock.c light.c main.c serial.c test.c ac.c command.c
  group include
    ./: command.h clock.h common.h light.h serial.h test.h ac.h
